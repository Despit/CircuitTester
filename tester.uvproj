# Keil uVision project tester.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: tester +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\keil
  group Source Group 1
    ./: STARTUP.A51
  group Link
    ./: main.c char.c delay.c oled.c spi.c ad0808.c ad9850.c
  group lib
    ./: char.h config.h delay.h oled.h spi.h AT89X52.H ad0808.h ad9850.h
